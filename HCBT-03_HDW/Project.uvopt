<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_opt.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <Extensions>
    <cExt>*.c</cExt>
    <aExt>*.s*; *.src; *.a*</aExt>
    <oExt>*.obj</oExt>
    <lExt>*.lib</lExt>
    <tExt>*.txt; *.h; *.inc</tExt>
    <pExt>*.plm</pExt>
    <CppX>*.cpp</CppX>
  </Extensions>

  <DaveTm>
    <dwLowDateTime>0</dwLowDateTime>
    <dwHighDateTime>0</dwHighDateTime>
  </DaveTm>

  <Target>
    <TargetName>YH08</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>12288000</CLKADS>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>1</RunSim>
        <RunTarget>0</RunTarget>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>.\Lst\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>1</IsCurrentTarget>
      </OPTFL>
      <CpuCode>255</CpuCode>
      <Books>
        <Book>
          <Number>0</Number>
          <Title>Reference Manual</Title>
          <Path>DATASHTS\ST\STM32F10xxx.PDF</Path>
        </Book>
      </Books>
      <DllOpt>
        <SimDllName>SARMCM3.DLL</SimDllName>
        <SimDllArguments></SimDllArguments>
        <SimDlgDllName>DARMSTM.DLL</SimDlgDllName>
        <SimDlgDllArguments>-pSTM32F103VB</SimDlgDllArguments>
        <TargetDllName>SARMCM3.DLL</TargetDllName>
        <TargetDllArguments></TargetDllArguments>
        <TargetDlgDllName>TARMSTM.DLL</TargetDlgDllName>
        <TargetDlgDllArguments>-pSTM32F103VB</TargetDlgDllArguments>
      </DllOpt>
      <DebugOpt>
        <uSim>0</uSim>
        <uTrg>1</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>1</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <nTsel>1</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon>BIN\UL2CM3.DLL</pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ULP2CM3</Key>
          <Name></Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>JL2CM3</Key>
          <Name>-U805306163 -O14 -S0 -A0 -C0 -JU1 -JI127.0.0.1 -JP0 -RST0 -N00("ARM CoreSight JTAG-DP") -D00(3BA00477) -L00(4) -N01("Unknown JTAG device") -D01(06414041) -L01(5) -TO18 -TC10000000 -TP21 -TDS8007 -TDT0 -TDC1F -TIEFFFFFFFF -TIP8 -TB1 -TFE0 -FO7 -FD20000000 -FC800 -FN1 -FF0STM32F10x_512 -FS08000000 -FL080000</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGUARM</Key>
          <Name>(105=-1,-1,-1,-1,0)(106=-1,-1,-1,-1,0)(107=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGTARM</Key>
          <Name>(1010=382,127,748,673,0)(1007=105,136,282,400,0)(1008=90,120,456,345,0)(1009=120,152,354,689,0)(100=-1,-1,-1,-1,0)(110=-1,-1,-1,-1,0)(111=-1,-1,-1,-1,0)(1011=-1,-1,-1,-1,0)(180=-1,-1,-1,-1,0)(120=-1,-1,-1,-1,0)(121=-1,-1,-1,-1,0)(122=-1,-1,-1,-1,0)(123=-1,-1,-1,-1,0)(124=-1,-1,-1,-1,0)(140=-1,-1,-1,-1,0)(240=-1,-1,-1,-1,0)(190=-1,-1,-1,-1,0)(200=-1,-1,-1,-1,0)(170=-1,-1,-1,-1,0)(130=-1,-1,-1,-1,0)(131=-1,-1,-1,-1,0)(132=-1,-1,-1,-1,0)(133=-1,-1,-1,-1,0)(160=-1,-1,-1,-1,0)(161=-1,-1,-1,-1,0)(162=-1,-1,-1,-1,0)(210=-1,-1,-1,-1,0)(211=-1,-1,-1,-1,0)(220=-1,-1,-1,-1,0)(221=-1,-1,-1,-1,0)(230=-1,-1,-1,-1,0)(231=-1,-1,-1,-1,0)(232=-1,-1,-1,-1,0)(233=-1,-1,-1,-1,0)(150=-1,-1,-1,-1,0)(151=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ST-LINKII-KEIL</Key>
          <Name>-S1 -B115200 -O0</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGDARM</Key>
          <Name>(1010=75,107,441,653,0)(1007=105,140,282,404,0)(1008=606,334,972,563,0)(1009=-1,-1,-1,-1,0)(100=388,102,1024,764,0)(110=51,130,255,585,0)(111=-1,-1,-1,-1,0)(1011=60,91,584,445,0)(180=-1,-1,-1,-1,0)(120=75,107,486,527,0)(121=-1,-1,-1,-1,0)(122=75,107,486,527,0)(123=-1,-1,-1,-1,0)(124=-1,-1,-1,-1,0)(125=613,0,1024,420,0)(126=75,107,486,527,0)(140=75,107,753,440,0)(240=582,183,971,521,0)(190=-1,-1,-1,-1,0)(200=-1,-1,-1,-1,0)(170=-1,-1,-1,-1,0)(130=440,19,1024,763,0)(131=440,24,1024,768,0)(132=396,0,980,744,0)(133=-1,-1,-1,-1,0)(160=206,350,644,757,0)(161=170,201,608,608,0)(162=-1,-1,-1,-1,0)(210=-1,-1,-1,-1,0)(211=180,221,497,572,0)(220=-1,-1,-1,-1,0)(221=-1,-1,-1,-1,0)(230=-1,-1,-1,-1,0)(234=-1,-1,-1,-1,0)(231=-1,-1,-1,-1,0)(232=-1,-1,-1,-1,0)(233=-1,-1,-1,-1,0)(150=0,24,593,768,0)(151=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMDBGFLAGS</Key>
          <Name>-T0</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>UL2CM3</Key>
          <Name>-UV0VVV123 -O14 -S0 -C0 -N00("ARM CoreSight JTAG-DP") -D00(3BA00477) -L00(4) -N01("ST TMC") -D01(16410041) -L01(5) -TO18 -TC10000000 -TP21 -TDS8007 -TDT0 -TDC1F -TIEFFFFFFFF -TIP8 -FO23 -FD20000000 -FC800 -FN1 -FF0STM32F10x_128 -FS08000000 -FL020000</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <WatchWindow1>
        <Ww>
          <count>0</count>
          <WinNumber>1</WinNumber>
          <ItemText>tocontinue</ItemText>
        </Ww>
        <Ww>
          <count>1</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_bMeasureBreak</ItemText>
        </Ww>
        <Ww>
          <count>2</count>
          <WinNumber>1</WinNumber>
          <ItemText>Pressure0</ItemText>
        </Ww>
        <Ww>
          <count>3</count>
          <WinNumber>1</WinNumber>
          <ItemText>Pressure1</ItemText>
        </Ww>
        <Ww>
          <count>4</count>
          <WinNumber>1</WinNumber>
          <ItemText>Pressure2</ItemText>
        </Ww>
        <Ww>
          <count>5</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lCf</ItemText>
        </Ww>
        <Ww>
          <count>6</count>
          <WinNumber>1</WinNumber>
          <ItemText>flag_count</ItemText>
        </Ww>
        <Ww>
          <count>7</count>
          <WinNumber>1</WinNumber>
          <ItemText>Num</ItemText>
        </Ww>
        <Ww>
          <count>8</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_bIgnoreConcentrationLow</ItemText>
        </Ww>
        <Ww>
          <count>9</count>
          <WinNumber>1</WinNumber>
          <ItemText>SelfCheckCount</ItemText>
        </Ww>
        <Ww>
          <count>10</count>
          <WinNumber>1</WinNumber>
          <ItemText>sleeptime</ItemText>
        </Ww>
        <Ww>
          <count>11</count>
          <WinNumber>1</WinNumber>
          <ItemText>chopperDelaytimes</ItemText>
        </Ww>
        <Ww>
          <count>12</count>
          <WinNumber>1</WinNumber>
          <ItemText>ReadBuffer</ItemText>
        </Ww>
        <Ww>
          <count>13</count>
          <WinNumber>1</WinNumber>
          <ItemText>flag_count</ItemText>
        </Ww>
        <Ww>
          <count>14</count>
          <WinNumber>1</WinNumber>
          <ItemText>SelfCheckCount</ItemText>
        </Ww>
        <Ww>
          <count>15</count>
          <WinNumber>1</WinNumber>
          <ItemText>ReadBuffer</ItemText>
        </Ww>
        <Ww>
          <count>16</count>
          <WinNumber>1</WinNumber>
          <ItemText>SelfCheckCount</ItemText>
        </Ww>
        <Ww>
          <count>17</count>
          <WinNumber>1</WinNumber>
          <ItemText>SelfCheckCount</ItemText>
        </Ww>
        <Ww>
          <count>18</count>
          <WinNumber>1</WinNumber>
          <ItemText>QualifyTimes</ItemText>
        </Ww>
        <Ww>
          <count>19</count>
          <WinNumber>1</WinNumber>
          <ItemText>Sys_Status</ItemText>
        </Ww>
        <Ww>
          <count>20</count>
          <WinNumber>1</WinNumber>
          <ItemText>n</ItemText>
        </Ww>
        <Ww>
          <count>21</count>
          <WinNumber>1</WinNumber>
          <ItemText>i</ItemText>
        </Ww>
        <Ww>
          <count>22</count>
          <WinNumber>1</WinNumber>
          <ItemText>Pressure1</ItemText>
        </Ww>
        <Ww>
          <count>23</count>
          <WinNumber>1</WinNumber>
          <ItemText>Pressure0</ItemText>
        </Ww>
        <Ww>
          <count>24</count>
          <WinNumber>1</WinNumber>
          <ItemText>debug2_collin</ItemText>
        </Ww>
        <Ww>
          <count>25</count>
          <WinNumber>1</WinNumber>
          <ItemText>debug1_collin</ItemText>
        </Ww>
        <Ww>
          <count>26</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_mesureType</ItemText>
        </Ww>
        <Ww>
          <count>27</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_mesureType</ItemText>
        </Ww>
        <Ww>
          <count>28</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_mesureType</ItemText>
        </Ww>
        <Ww>
          <count>29</count>
          <WinNumber>1</WinNumber>
          <ItemText>qualityCount</ItemText>
        </Ww>
        <Ww>
          <count>30</count>
          <WinNumber>1</WinNumber>
          <ItemText>ch_selected</ItemText>
        </Ww>
        <Ww>
          <count>31</count>
          <WinNumber>1</WinNumber>
          <ItemText>qualityCount</ItemText>
        </Ww>
        <Ww>
          <count>32</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_mesureType</ItemText>
        </Ww>
        <Ww>
          <count>33</count>
          <WinNumber>1</WinNumber>
          <ItemText>flag_count</ItemText>
        </Ww>
        <Ww>
          <count>34</count>
          <WinNumber>1</WinNumber>
          <ItemText>MenuIndex</ItemText>
        </Ww>
        <Ww>
          <count>35</count>
          <WinNumber>1</WinNumber>
          <ItemText>CONFIRM</ItemText>
        </Ww>
        <Ww>
          <count>36</count>
          <WinNumber>1</WinNumber>
          <ItemText>sampleTooless</ItemText>
        </Ww>
        <Ww>
          <count>37</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_bMeasureBreak</ItemText>
        </Ww>
        <Ww>
          <count>38</count>
          <WinNumber>1</WinNumber>
          <ItemText>checkChannel</ItemText>
        </Ww>
        <Ww>
          <count>39</count>
          <WinNumber>1</WinNumber>
          <ItemText>n</ItemText>
        </Ww>
        <Ww>
          <count>40</count>
          <WinNumber>1</WinNumber>
          <ItemText>n</ItemText>
        </Ww>
        <Ww>
          <count>41</count>
          <WinNumber>1</WinNumber>
          <ItemText>TripSwitchStatus</ItemText>
        </Ww>
        <Ww>
          <count>42</count>
          <WinNumber>1</WinNumber>
          <ItemText>cw_status</ItemText>
        </Ww>
        <Ww>
          <count>43</count>
          <WinNumber>1</WinNumber>
          <ItemText>PulseCount</ItemText>
        </Ww>
        <Ww>
          <count>44</count>
          <WinNumber>1</WinNumber>
          <ItemText>debug2_collin</ItemText>
        </Ww>
        <Ww>
          <count>45</count>
          <WinNumber>1</WinNumber>
          <ItemText>debug_collin3</ItemText>
        </Ww>
        <Ww>
          <count>46</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>47</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>48</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>49</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>50</count>
          <WinNumber>1</WinNumber>
          <ItemText>cbc12</ItemText>
        </Ww>
        <Ww>
          <count>51</count>
          <WinNumber>1</WinNumber>
          <ItemText>csc12</ItemText>
        </Ww>
        <Ww>
          <count>52</count>
          <WinNumber>1</WinNumber>
          <ItemText>cbc13</ItemText>
        </Ww>
        <Ww>
          <count>53</count>
          <WinNumber>1</WinNumber>
          <ItemText>csc13</ItemText>
        </Ww>
        <Ww>
          <count>54</count>
          <WinNumber>1</WinNumber>
          <ItemText>csc13</ItemText>
        </Ww>
        <Ww>
          <count>55</count>
          <WinNumber>1</WinNumber>
          <ItemText>ratebase</ItemText>
        </Ww>
        <Ww>
          <count>56</count>
          <WinNumber>1</WinNumber>
          <ItemText>ratesample</ItemText>
        </Ww>
        <Ww>
          <count>57</count>
          <WinNumber>1</WinNumber>
          <ItemText>dob</ItemText>
        </Ww>
        <Ww>
          <count>58</count>
          <WinNumber>1</WinNumber>
          <ItemText>C12BABS</ItemText>
        </Ww>
        <Ww>
          <count>59</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lC12B</ItemText>
        </Ww>
        <Ww>
          <count>60</count>
          <WinNumber>1</WinNumber>
          <ItemText>C12SABS</ItemText>
        </Ww>
        <Ww>
          <count>61</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lC12S</ItemText>
        </Ww>
        <Ww>
          <count>62</count>
          <WinNumber>1</WinNumber>
          <ItemText>Per</ItemText>
        </Ww>
        <Ww>
          <count>63</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_bDilution</ItemText>
        </Ww>
        <Ww>
          <count>64</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>65</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>66</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>67</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>68</count>
          <WinNumber>1</WinNumber>
          <ItemText>cbc12</ItemText>
        </Ww>
        <Ww>
          <count>69</count>
          <WinNumber>1</WinNumber>
          <ItemText>csc12</ItemText>
        </Ww>
        <Ww>
          <count>70</count>
          <WinNumber>1</WinNumber>
          <ItemText>cbc13</ItemText>
        </Ww>
        <Ww>
          <count>71</count>
          <WinNumber>1</WinNumber>
          <ItemText>csc13</ItemText>
        </Ww>
        <Ww>
          <count>72</count>
          <WinNumber>1</WinNumber>
          <ItemText>ratebase</ItemText>
        </Ww>
        <Ww>
          <count>73</count>
          <WinNumber>1</WinNumber>
          <ItemText>ratesample</ItemText>
        </Ww>
        <Ww>
          <count>74</count>
          <WinNumber>1</WinNumber>
          <ItemText>dob</ItemText>
        </Ww>
        <Ww>
          <count>75</count>
          <WinNumber>1</WinNumber>
          <ItemText>Percent</ItemText>
        </Ww>
        <Ww>
          <count>76</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lCfC12</ItemText>
        </Ww>
        <Ww>
          <count>77</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lCfC13</ItemText>
        </Ww>
        <Ww>
          <count>78</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>79</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>80</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>81</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>82</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>83</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>84</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>85</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>86</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>87</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>88</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>89</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>90</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>91</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>92</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>93</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>94</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>95</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>96</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>97</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>98</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>99</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>100</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>101</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>102</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>103</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>104</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>105</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>106</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>107</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>108</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>109</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>110</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>111</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>112</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>113</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>114</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>115</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>116</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>117</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>118</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>119</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>120</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>121</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>122</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>123</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>124</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>125</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>126</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>127</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>128</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>129</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>130</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>131</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>132</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>133</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>134</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>135</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>136</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>137</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>138</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>139</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>140</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>141</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>142</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>143</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>144</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>145</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>146</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>147</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>148</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>149</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>150</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>151</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>152</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>153</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>154</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>155</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>156</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>157</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>158</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>159</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lCfC12</ItemText>
        </Ww>
        <Ww>
          <count>160</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lCfC12</ItemText>
        </Ww>
        <Ww>
          <count>161</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lCfC13</ItemText>
        </Ww>
        <Ww>
          <count>162</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lCfC12</ItemText>
        </Ww>
        <Ww>
          <count>163</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lCfC13</ItemText>
        </Ww>
        <Ww>
          <count>164</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>165</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>166</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>167</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>168</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>169</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>170</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>171</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>172</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>173</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>174</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>175</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>176</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>177</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>178</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>179</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>180</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>181</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>182</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>183</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>184</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>185</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>186</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>187</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>188</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>189</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>190</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>191</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>192</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>193</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>194</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>195</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>196</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>197</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>198</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>199</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>200</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>201</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>202</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>203</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>204</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>205</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>206</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>207</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>208</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>209</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>210</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>211</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>212</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>213</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>214</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>215</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>216</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>217</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>218</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>219</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>220</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>221</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>222</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>223</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>224</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>225</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>226</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>227</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>228</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>229</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>230</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>231</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>232</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>233</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>234</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>235</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>236</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>237</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>238</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>239</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>240</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>241</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>242</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>243</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>244</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>245</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>246</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>247</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>248</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>249</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>250</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>251</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>252</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>253</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>254</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>255</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>256</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>257</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>258</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>259</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>260</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>261</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>262</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>263</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>264</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>265</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>266</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>267</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>268</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>269</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>270</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>271</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>272</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lCfC12</ItemText>
        </Ww>
        <Ww>
          <count>273</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lCfC13</ItemText>
        </Ww>
        <Ww>
          <count>274</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>275</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>276</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>277</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>278</count>
          <WinNumber>1</WinNumber>
          <ItemText>cbc12</ItemText>
        </Ww>
        <Ww>
          <count>279</count>
          <WinNumber>1</WinNumber>
          <ItemText>csc12</ItemText>
        </Ww>
        <Ww>
          <count>280</count>
          <WinNumber>1</WinNumber>
          <ItemText>cbc13</ItemText>
        </Ww>
        <Ww>
          <count>281</count>
          <WinNumber>1</WinNumber>
          <ItemText>csc13</ItemText>
        </Ww>
        <Ww>
          <count>282</count>
          <WinNumber>1</WinNumber>
          <ItemText>ratebase</ItemText>
        </Ww>
        <Ww>
          <count>283</count>
          <WinNumber>1</WinNumber>
          <ItemText>ratesample</ItemText>
        </Ww>
        <Ww>
          <count>284</count>
          <WinNumber>1</WinNumber>
          <ItemText>A1</ItemText>
        </Ww>
        <Ww>
          <count>285</count>
          <WinNumber>1</WinNumber>
          <ItemText>A2</ItemText>
        </Ww>
        <Ww>
          <count>286</count>
          <WinNumber>1</WinNumber>
          <ItemText>A3</ItemText>
        </Ww>
        <Ww>
          <count>287</count>
          <WinNumber>1</WinNumber>
          <ItemText>A4</ItemText>
        </Ww>
        <Ww>
          <count>288</count>
          <WinNumber>1</WinNumber>
          <ItemText>A4</ItemText>
        </Ww>
        <Ww>
          <count>289</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>290</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>291</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>292</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>293</count>
          <WinNumber>1</WinNumber>
          <ItemText>cbc12</ItemText>
        </Ww>
        <Ww>
          <count>294</count>
          <WinNumber>1</WinNumber>
          <ItemText>csc12</ItemText>
        </Ww>
        <Ww>
          <count>295</count>
          <WinNumber>1</WinNumber>
          <ItemText>cbc13</ItemText>
        </Ww>
        <Ww>
          <count>296</count>
          <WinNumber>1</WinNumber>
          <ItemText>csc13</ItemText>
        </Ww>
        <Ww>
          <count>297</count>
          <WinNumber>1</WinNumber>
          <ItemText>csc13</ItemText>
        </Ww>
        <Ww>
          <count>298</count>
          <WinNumber>1</WinNumber>
          <ItemText>dob</ItemText>
        </Ww>
        <Ww>
          <count>299</count>
          <WinNumber>1</WinNumber>
          <ItemText>ratebase</ItemText>
        </Ww>
        <Ww>
          <count>300</count>
          <WinNumber>1</WinNumber>
          <ItemText>ratesample</ItemText>
        </Ww>
        <Ww>
          <count>301</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\YH08\function.c\xbc12</ItemText>
        </Ww>
        <Ww>
          <count>302</count>
          <WinNumber>1</WinNumber>
          <ItemText>C12</ItemText>
        </Ww>
        <Ww>
          <count>303</count>
          <WinNumber>1</WinNumber>
          <ItemText>C13</ItemText>
        </Ww>
        <Ww>
          <count>304</count>
          <WinNumber>1</WinNumber>
          <ItemText>Intensity1</ItemText>
        </Ww>
        <Ww>
          <count>305</count>
          <WinNumber>1</WinNumber>
          <ItemText>Intensity2</ItemText>
        </Ww>
        <Ww>
          <count>306</count>
          <WinNumber>1</WinNumber>
          <ItemText>PHead</ItemText>
        </Ww>
        <Ww>
          <count>307</count>
          <WinNumber>1</WinNumber>
          <ItemText>PEnd</ItemText>
        </Ww>
        <Ww>
          <count>308</count>
          <WinNumber>1</WinNumber>
          <ItemText>C12BABS</ItemText>
        </Ww>
        <Ww>
          <count>309</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lC12B</ItemText>
        </Ww>
        <Ww>
          <count>310</count>
          <WinNumber>1</WinNumber>
          <ItemText>C12SABS</ItemText>
        </Ww>
        <Ww>
          <count>311</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lC12S</ItemText>
        </Ww>
        <Ww>
          <count>312</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>313</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>314</count>
          <WinNumber>1</WinNumber>
          <ItemText>cbc12</ItemText>
        </Ww>
        <Ww>
          <count>315</count>
          <WinNumber>1</WinNumber>
          <ItemText>csc12</ItemText>
        </Ww>
        <Ww>
          <count>316</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lCfC12</ItemText>
        </Ww>
        <Ww>
          <count>317</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lCfC12</ItemText>
        </Ww>
        <Ww>
          <count>318</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lCfC12</ItemText>
        </Ww>
        <Ww>
          <count>319</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lCfC12_backup</ItemText>
        </Ww>
        <Ww>
          <count>320</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lCfC13</ItemText>
        </Ww>
        <Ww>
          <count>321</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>322</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>323</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>324</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>325</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lCfC12</ItemText>
        </Ww>
        <Ww>
          <count>326</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lCfC13</ItemText>
        </Ww>
        <Ww>
          <count>327</count>
          <WinNumber>1</WinNumber>
          <ItemText>cbc13</ItemText>
        </Ww>
        <Ww>
          <count>328</count>
          <WinNumber>1</WinNumber>
          <ItemText>csc13</ItemText>
        </Ww>
        <Ww>
          <count>329</count>
          <WinNumber>1</WinNumber>
          <ItemText>csc13</ItemText>
        </Ww>
        <Ww>
          <count>330</count>
          <WinNumber>1</WinNumber>
          <ItemText>dob</ItemText>
        </Ww>
        <Ww>
          <count>331</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_mesureType</ItemText>
        </Ww>
        <Ww>
          <count>332</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_mesureType</ItemText>
        </Ww>
        <Ww>
          <count>333</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_mesureType</ItemText>
        </Ww>
        <Ww>
          <count>334</count>
          <WinNumber>1</WinNumber>
          <ItemText>COUNT</ItemText>
        </Ww>
        <Ww>
          <count>335</count>
          <WinNumber>1</WinNumber>
          <ItemText>upperCount</ItemText>
        </Ww>
        <Ww>
          <count>336</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lC12B</ItemText>
        </Ww>
        <Ww>
          <count>337</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lC12S</ItemText>
        </Ww>
        <Ww>
          <count>338</count>
          <WinNumber>1</WinNumber>
          <ItemText>SelfCheckCount</ItemText>
        </Ww>
        <Ww>
          <count>339</count>
          <WinNumber>1</WinNumber>
          <ItemText>A1</ItemText>
        </Ww>
        <Ww>
          <count>340</count>
          <WinNumber>1</WinNumber>
          <ItemText>A2</ItemText>
        </Ww>
        <Ww>
          <count>341</count>
          <WinNumber>1</WinNumber>
          <ItemText>absC12</ItemText>
        </Ww>
        <Ww>
          <count>342</count>
          <WinNumber>1</WinNumber>
          <ItemText>absC13</ItemText>
        </Ww>
        <Ww>
          <count>343</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lCfC12</ItemText>
        </Ww>
        <Ww>
          <count>344</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_lCfC13</ItemText>
        </Ww>
        <Ww>
          <count>345</count>
          <WinNumber>1</WinNumber>
          <ItemText>Intensitys</ItemText>
        </Ww>
        <Ww>
          <count>346</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>347</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>348</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>349</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>350</count>
          <WinNumber>1</WinNumber>
          <ItemText>ID_NUM</ItemText>
        </Ww>
        <Ww>
          <count>351</count>
          <WinNumber>1</WinNumber>
          <ItemText>ID</ItemText>
        </Ww>
        <Ww>
          <count>352</count>
          <WinNumber>1</WinNumber>
          <ItemText>Num</ItemText>
        </Ww>
        <Ww>
          <count>353</count>
          <WinNumber>1</WinNumber>
          <ItemText>Num</ItemText>
        </Ww>
        <Ww>
          <count>354</count>
          <WinNumber>1</WinNumber>
          <ItemText>Num</ItemText>
        </Ww>
        <Ww>
          <count>355</count>
          <WinNumber>1</WinNumber>
          <ItemText>ID_NUM</ItemText>
        </Ww>
        <Ww>
          <count>356</count>
          <WinNumber>1</WinNumber>
          <ItemText>Intensitys</ItemText>
        </Ww>
        <Ww>
          <count>357</count>
          <WinNumber>1</WinNumber>
          <ItemText>ratebase</ItemText>
        </Ww>
        <Ww>
          <count>358</count>
          <WinNumber>1</WinNumber>
          <ItemText>ratesample</ItemText>
        </Ww>
        <Ww>
          <count>359</count>
          <WinNumber>1</WinNumber>
          <ItemText>ratebase</ItemText>
        </Ww>
        <Ww>
          <count>360</count>
          <WinNumber>1</WinNumber>
          <ItemText>dob</ItemText>
        </Ww>
        <Ww>
          <count>361</count>
          <WinNumber>1</WinNumber>
          <ItemText>I13bs</ItemText>
        </Ww>
        <Ww>
          <count>362</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>363</count>
          <WinNumber>1</WinNumber>
          <ItemText>m_mesureType</ItemText>
        </Ww>
        <Ww>
          <count>364</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>365</count>
          <WinNumber>1</WinNumber>
          <ItemText>ratebase</ItemText>
        </Ww>
        <Ww>
          <count>366</count>
          <WinNumber>1</WinNumber>
          <ItemText>ratesample</ItemText>
        </Ww>
        <Ww>
          <count>367</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc12</ItemText>
        </Ww>
        <Ww>
          <count>368</count>
          <WinNumber>1</WinNumber>
          <ItemText>xbc13</ItemText>
        </Ww>
        <Ww>
          <count>369</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc12</ItemText>
        </Ww>
        <Ww>
          <count>370</count>
          <WinNumber>1</WinNumber>
          <ItemText>xsc13</ItemText>
        </Ww>
        <Ww>
          <count>371</count>
          <WinNumber>1</WinNumber>
          <ItemText>dob</ItemText>
        </Ww>
        <Ww>
          <count>372</count>
          <WinNumber>1</WinNumber>
          <ItemText>I13bs</ItemText>
        </Ww>
        <Ww>
          <count>373</count>
          <WinNumber>1</WinNumber>
          <ItemText>Tbs</ItemText>
        </Ww>
        <Ww>
          <count>374</count>
          <WinNumber>1</WinNumber>
          <ItemText>ratebase</ItemText>
        </Ww>
        <Ww>
          <count>375</count>
          <WinNumber>1</WinNumber>
          <ItemText>ratesample</ItemText>
        </Ww>
        <Ww>
          <count>376</count>
          <WinNumber>1</WinNumber>
          <ItemText>dob_debug</ItemText>
        </Ww>
        <Ww>
          <count>377</count>
          <WinNumber>1</WinNumber>
          <ItemText>ratebase_debug</ItemText>
        </Ww>
        <Ww>
          <count>378</count>
          <WinNumber>1</WinNumber>
          <ItemText>ratesample_debug</ItemText>
        </Ww>
        <Ww>
          <count>379</count>
          <WinNumber>1</WinNumber>
          <ItemText>SendLength_uart1</ItemText>
        </Ww>
        <Ww>
          <count>380</count>
          <WinNumber>1</WinNumber>
          <ItemText>SendCounter_uart1</ItemText>
        </Ww>
        <Ww>
          <count>381</count>
          <WinNumber>1</WinNumber>
          <ItemText>QueryFlag_uart1</ItemText>
        </Ww>
        <Ww>
          <count>382</count>
          <WinNumber>1</WinNumber>
          <ItemText>SendCounter_uart1</ItemText>
        </Ww>
        <Ww>
          <count>383</count>
          <WinNumber>1</WinNumber>
          <ItemText>retry</ItemText>
        </Ww>
      </WatchWindow1>
      <WatchWindow2>
        <Ww>
          <count>0</count>
          <WinNumber>2</WinNumber>
          <ItemText>lBUFMAG</ItemText>
        </Ww>
        <Ww>
          <count>1</count>
          <WinNumber>2</WinNumber>
          <ItemText>ToMeasPosition</ItemText>
        </Ww>
      </WatchWindow2>
      <MemoryWindow1>
        <Mm>
          <WinNumber>1</WinNumber>
          <SubType>0</SubType>
          <ItemText>\\YH08\motion.c\ToMeasPosition[0]</ItemText>
        </Mm>
      </MemoryWindow1>
      <DebugFlag>
        <trace>0</trace>
        <periodic>0</periodic>
        <aLwin>1</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>1</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>0</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
    </TargetOption>
  </Target>

  <Group>
    <GroupName>User</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>1</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>14</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>48</TopLine>
      <CurrentLine>54</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>2</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>34</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>442</TopLine>
      <CurrentLine>447</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\stm32f10x_it.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_it.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>3</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>40</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>487</TopLine>
      <CurrentLine>499</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\function.c</PathWithFileName>
      <FilenameWithoutPath>function.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>4</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>44</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>290</TopLine>
      <CurrentLine>308</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\max1168.c</PathWithFileName>
      <FilenameWithoutPath>max1168.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>RVMDK</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>5</FileNumber>
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>295</TopLine>
      <CurrentLine>295</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\stm32f10x_vector.s</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_vector.s</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>Lib</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>6</FileNumber>
      <FileType>4</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\STM32F10xR.LIB</PathWithFileName>
      <FilenameWithoutPath>STM32F10xR.LIB</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>DSP_Lib</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>7</FileNumber>
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\DSP_Lib\src\cr4_fft_256_stm32.s</PathWithFileName>
      <FilenameWithoutPath>cr4_fft_256_stm32.s</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>8</FileNumber>
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\DSP_Lib\src\cr4_fft_1024_stm32.s</PathWithFileName>
      <FilenameWithoutPath>cr4_fft_1024_stm32.s</FilenameWithoutPath>
    </File>
  </Group>

</ProjectOpt>
